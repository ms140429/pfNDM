# Keil uVision project fe fu.uvprojx, settings and files
target fe fu (6190000::V6.19::ARMCLANG)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.6.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: fe fu +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32H743xx
  c include: ../Core/Inc;../X-CUBE-AI/App;../X-CUBE-AI;../X-CUBE-AI/Target;../Middlewares/ST/AI/Inc;../Drivers/CMSIS/Include;../Drivers/LCD;../Drivers/MPU;../Drivers/sys;../Drivers/delay;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32H7xx/Include
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: fe fu.sct
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Application/User/X-CUBE-AI/App
    ../X-CUBE-AI/App/: network_f01.c network_f01_data.c network_f01_data_params.c aiSystemPerformance.c aiTestHelper.c aiTestUtility.c ai_device_adaptor.c lc_print.c syscalls.c network_fu.c network_fu_data.c network_fu_data_params.c network_fx.c network_fx_data.c network_fx_data_params.c network_fy.c network_fy_data.c network_fy_data_params.c network_f02.c network_f02_data.c network_f02_data_params.c app_x-cube-ai.c
  group Application/User/Core
    ../Drivers/delay/: delay.c
    ../Drivers/sys/: sys.c
    ../Drivers/LCD/: lcd.c
    ../Core/Src/: main.c gpio.c crc.c fmc.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Doc
    ../X-CUBE-AI/App/: network_f01_generate_report.txt network_fu_generate_report.txt network_fx_generate_report.txt network_fy_generate_report.txt network_f02_generate_report.txt
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_ll_fmc.c stm32h7xx_hal_sram.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Lib
    ../Middlewares/ST/AI/Lib/: NetworkRuntime810_CM7_Keil.lib
software components: CMSIS:CORE 5.6.0
